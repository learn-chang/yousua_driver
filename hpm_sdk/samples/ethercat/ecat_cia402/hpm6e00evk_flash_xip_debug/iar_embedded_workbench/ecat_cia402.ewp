# IAR project ecat_cia402.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM6E80xVMx HPMicro HPM6E80xVMx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDMLITE=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_MTG=y; HPMSOC_HAS_HPMSDK_VSC=y; HPMSOC_HAS_HPMSDK_CLC=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_TSW=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_FFA=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_BACC=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_MCL_HAS_EXTRA_CONFIG="mcl_app_config.h"; CONFIG_CIA402_USING_ACTUAL_MOTOR=1
  ICCRISCV.CCIncludePath2: ../../../../../arch; ../../../../../arch/riscv/l1c; ../../../../../arch/riscv/intc; ../../../../../boards/hpm6e00evk; ../../../../../soc/HPM6E00/HPM6E80; ../../../../../soc/HPM6E00/ip; ../../../../../soc/HPM6E00/HPM6E80/toolchains; ../../../../../soc/HPM6E00/HPM6E80/boot; ../../../../../drivers/inc; ../../../../../utils; ../../../../../components/debug_console; ../../../../../components/adc; ../../../../../components/eeprom_emulation; ../../../../../components/eeprom_emulation/port; ../../../../../middleware/hpm_mcl_v2; ../../../../../middleware/hpm_mcl_v2/encoder; ../../../../../middleware/hpm_mcl_v2/drivers; ../../../../../middleware/hpm_mcl_v2/core/sensor; ../../../../../middleware/hpm_mcl_v2/core/drivers; ../../../../../middleware/hpm_mcl_v2/core/loop; ../../../../../middleware/hpm_mcl_v2/core/detect; ../../../../../middleware/hpm_mcl_v2/core/control; ../build_tmp/generated/include; ../../motor; ../../SSC/Src; ../../../port; ../..
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=16M; _extram_size=32M; _noncacheable_size=256K
  ILINK.IlinkIcfFile: ..\..\..\..\..\soc\HPM6E00\HPM6E80\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_MULTICORE=y; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_I2S=y; HPMSOC_HAS_HPMSDK_DAO=y; HPMSOC_HAS_HPMSDK_PDMLITE=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_MTG=y; HPMSOC_HAS_HPMSDK_VSC=y; HPMSOC_HAS_HPMSDK_CLC=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_TSW=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_FEMC=y; HPMSOC_HAS_HPMSDK_FFA=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_PSEC=y; HPMSOC_HAS_HPMSDK_PMON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_BACC=y; HPMSOC_HAS_HPMSDK_BPOR=y; HPMSOC_HAS_HPMSDK_BCFG=y; HPMSOC_HAS_HPMSDK_BGPR=y; HPMSOC_HAS_HPMSDK_BSEC=y; HPMSOC_HAS_HPMSDK_RTC=y; HPMSOC_HAS_HPMSDK_BKEY=y; HPMSOC_HAS_HPMSDK_BMON=y; HPMSOC_HAS_HPMSDK_TAMP=y; HPMSOC_HAS_HPMSDK_MONO=y; HPMSOC_HAS_HPMSDK_PMP=y; CONFIG_MCL_HAS_EXTRA_CONFIG="mcl_app_config.h"; CONFIG_CIA402_USING_ACTUAL_MOTOR=1; NDEBUG
  group sdk_sample/ethercat/ecat_cia402
    ../../: ecat_cia402.c
  group sdk_sample/ethercat/ecat_cia402/motor
    ../../motor/: bldc_foc.c
  group sdk_sample/ethercat/ecat_cia402/SSC/Src
    ../../SSC/Src/: cia402appl.c coeappl.c ecatappl.c ecatcoe.c ecatslv.c mailbox.c objdef.c sdoserv.c
  group sdk_sample/ethercat/port
    ../../../port/: hpm_ecat_hw.c hpm_ecat_phy.c hpm_ecat_e2p_emulation.c
  group soc/HPM6E00/HPM6E80
    ../../../../../soc/HPM6E00/HPM6E80/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c hpm_trgm_soc_drv.c hpm_qeiv2_soc_drv.c
  group soc/HPM6E00/HPM6E80/toolchains
    ../../../../../soc/HPM6E00/HPM6E80/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM6E00/HPM6E80/toolchains/iar
    ../../../../../soc/HPM6E00/HPM6E80/toolchains/iar/: startup.s
  group soc/HPM6E00/HPM6E80/boot
    ../../../../../soc/HPM6E00/HPM6E80/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../../../arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm6e00evk
    ../../../../../boards/hpm6e00evk/: pinmux.c board.c
  group drivers/src
    ../../../../../drivers/src/: hpm_uart_drv.c hpm_femc_drv.c hpm_sdp_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_mtg_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwmv2_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_rtc_drv.c hpm_acmp_drv.c hpm_i2s_drv.c hpm_dao_drv.c hpm_pdmlite_drv.c hpm_enet_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_ffa_drv.c hpm_tsns_drv.c hpm_crc_drv.c hpm_sdm_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_sei_drv.c hpm_qeov2_drv.c hpm_rdc_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_tamp_drv.c hpm_vsc_drv.c hpm_clc_drv.c hpm_esc_drv.c hpm_ppi_drv.c hpm_lobs_drv.c hpm_tsw_drv.c
  group utils
    ../../../../../utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../components/debug_console/: hpm_debug_console.c
  group components/eeprom_emulation
    ../../../../../components/eeprom_emulation/: eeprom_emulation.c
  group components/eeprom_emulation/port
    ../../../../../components/eeprom_emulation/port/: hpm_nor_flash.c
  group middleware/hpm_mcl_v2/encoder
    ../../../../../middleware/hpm_mcl_v2/encoder/: hpm_mcl_abz.c hpm_mcl_uvw.c
  group middleware/hpm_mcl_v2/drivers
    ../../../../../middleware/hpm_mcl_v2/drivers/: hpm_mcl_hw_loop.c
  group middleware/hpm_mcl_v2/core/sensor
    ../../../../../middleware/hpm_mcl_v2/core/sensor/: hpm_mcl_encoder.c hpm_mcl_analog.c
  group middleware/hpm_mcl_v2/core/drivers
    ../../../../../middleware/hpm_mcl_v2/core/drivers/: hpm_mcl_drivers.c
  group middleware/hpm_mcl_v2/core/loop
    ../../../../../middleware/hpm_mcl_v2/core/loop/: hpm_mcl_loop.c hpm_mcl_debug.c
  group middleware/hpm_mcl_v2/core/detect
    ../../../../../middleware/hpm_mcl_v2/core/detect/: hpm_mcl_detect.c
  group middleware/hpm_mcl_v2/core/control
    ../../../../../middleware/hpm_mcl_v2/core/control/: hpm_mcl_control.c hpm_mcl_filter.c hpm_mcl_path_plan.c hpm_mcl_hybrid_ctrl.c
