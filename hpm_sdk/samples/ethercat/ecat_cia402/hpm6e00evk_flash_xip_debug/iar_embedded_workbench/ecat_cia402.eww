<?xml version="1.0" encoding="UTF-8"?>
<workspace>
<project>
<path>$WS_DIR$\ecat_cia402.ewp</path>
</project>
<batchBuild />
</workspace>